# Keil uVision project CortexM3_Test.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CortexM3_Test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=4 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: .\Code\lib\CMSIS_5\CMSIS\Core\Include;.\Code\lib\STM32Cube_FW_F1\Drivers\CMSIS\Device\ST\STM32F1xx\Include;.\Code\lib\STM32Cube_FW_F1\Drivers\STM32F1xx_HAL_Driver\Inc;.\Code\MCU;.\Code\Main;.\Code\User;..\..\Code\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ./Code/Main/: main.c
  group MCU
    ./Code/MCU/: stm32f1xx_it.c
  group Lib\ST
    ./Code/Lib/STM32Cube_FW_F1/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ./Code/Lib/STM32Cube_FW_F1/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group Lib\HAL
    ./Code/Lib/STM32Cube_FW_F1/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim_ex.c
  group Lib\XCOS
    ../../Code/: XC_List.c XC_Sch.c XC_Task.c XC_Time.c
