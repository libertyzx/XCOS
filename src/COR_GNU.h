/*=========================================================|
 | 文件名: COR_GNU.h
 | 描述  : 协程库(GNU-C实现)
 | 版本  : V0.3
 | 日期  : 2023/12/21
 | 语言  : C语言
 | 作者  : libertyzx
 | E-mail: libertyzx@163.com
 +-----------------------------------------------|
 | 开源协议: MIT License
 +-----------------------------------------------|
 +--- 说明
 |  1. 宏"__LINE__"
 |      这个宏表示取当前文件当前代码的行号
 |  2. 由"goto label"实现;
 +-----------------------------------------------|
 +--- 版本说明
 |  V0.01:-2018/04/16
 |      1. 初始化代码
 |  V0.02:-2022/08/15
 |      1.修改断点在断点标号前加'_',为了防止数字开头的文件,导致标号不符合c语言规范;
 |      2."_COR_End"添加goto结束断点;
 |  V0.03:-2023/12/21
 |      1.增加"_COR_Break"直接跳出协程;
 *========================================================*/
//=== 防重复定义
#ifndef _COR_GNU_h_
#define _COR_GNU_h_
//=== 头文件
/*
 ************************************************************************************************************|
 ************************************************ 我是分割线 ************************************************|
 ************************************************************************************************************|
 */
//=== 数据类型 ============================================|
/*- 协程断点类型*/
    typedef void* COR_BP_t;         //协程断点类型

/*
 ************************************************************************************************************|
 ************************************************ 我是分割线 ************************************************|
 ************************************************************************************************************|
 */
//=== 基础函数宏 ==============================================================|
/************************************************|
 * 描述:    协程-组合断点标志
 * 宏名:    _COR_BP
 * 参数[I]: S1      //组合数据1
 * 参数[I]: S2      //组合数据2
 * 返回:    无
 * 说明:    需要展开两次所以有"_COR_BP2"
 ************************************************/
#define _COR_BP2(S1, S2)    _##S1##S2
#define _COR_BP(S1, S2)     _COR_BP2(S1, S2)

/************************************************|
 * 描述:    协程-断点初始化
 * 宏名:    _COR_Init
 * 参数[I]: TypeCOR_BP BP   //协程断点
 * 返回:    无
 * 说明:    无
 ************************************************/
#define _COR_Init(BP)       ( (BP) = NULL )

/************************************************|
 * 描述:    协程-代码开头
 * 宏名:    _COR_Start
 * 参数[I]: TypeCOR_BP BP   //协程断点
 * 返回:    无
 * 说明:    协程开头
 ************************************************/
#define _COR_Start(BP)      \
    do{                     \
        if(BP != NULL){     \
            goto *BP;       \
        }                   \
    }while(0)

/************************************************|
 * 描述:    协程-设置断点
 * 宏名:    _COR_SetBP
 * 参数[I]: TypeCOR_BP BP   //协程断点
 * 返回:    无
 * 说明:    无
 ************************************************/
#define _COR_SetBP(BP)                                                      \
    do{                                                                     \
    /*保存并设置断点(函数名+行号)*/                                         \
        (BP) = &&_COR_BP(__func__, __LINE__); _COR_BP(__func__, __LINE__):; \
    }while(0)

/************************************************|
 * 描述:    协程-跳出
 * 宏名:    _COR_Break
 * 参数[I]: TypeCOR_BP BP   //协程断点
 * 返回:    无
 * 说明:    直接跳出协程
 ************************************************/
#define  _COR_Break(BP)     \
    goto _XCCOR_GOTO_End;

/************************************************|
 * 描述:    协程-设置断点并跳出
 * 宏名:    _COR_SetBPBreak
 * 参数[I]: TypeCOR_BP BP   //协程断点
 * 返回:    无
 * 说明:    无
 ************************************************/
#define _COR_SetBPBreak(BP)                                                                         \
    do{                                                                                             \
    /*保存并设置断点(函数名+行号)然后跳出*/                                                         \
        (BP) = &&_COR_BP(__func__, __LINE__); goto _XCCOR_GOTO_End; _COR_BP(__func__, __LINE__):;   \
    }while(0)

/************************************************|
 * 描述:    协程-代码结束
 * 宏名:    _COR_End
 * 参数[I]: TypeCOR_BP BP   //协程断点
 * 返回:    无
 * 说明:    协程结尾
 ************************************************/
#define _COR_End(BP)    \
    _XCCOR_GOTO_End:    /*结束跳转标志*/

/*
 ************************************************************************************************************|
 ************************************************ 我是分割线 ************************************************|
 ************************************************************************************************************|
 */
//=== 文件结束
#endif
